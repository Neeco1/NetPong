# Keil uVision project netpong_s6e2ccxj.uvprojx, settings and files
target S6E2CCA_Debug (6090000::V6.9::.\ARMCLANG)
  device: S6E2CCAJ0A Cypress
  pack: Keil.FM4_DFP.1.5.1
  cpu: IRAM(0x1FFD0000,0x30000) IRAM2(0x20038000,0x10000) IROM(0x00000000,0x200000) IROM2(0x00406000,0xA000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: netpong_s6e2ccxj +hex
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\common;..\..\..\..\..\cmsis\include;..\..\..\Microcontroller\Cypress\PDL;..\..\..\PDL\2.1.0\cmsis\include;..\..\..\PDL\2.1.0\drivers;..\..\..\PDL\2.1.0\devices\fm4\s6e2ccxj\common;.\include;..\..\..\PDL\2.1.0\utilities\;.\lib
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x406000 size 0xa000
  memory RVCT9: RAM 0x1ffd0000 size 0x30000
  memory RVCT10: RAM 0x20038000 size 0x10000
  scatter file: .\linker\s6e2cca_rom.sct
  group common
    common/: system_s6e2cc.c
  group source
    ./: main.c
    ./: startup_s6e2cc.s
    ./lib/: itoa.h
  group drivers
    ../../../PDL/2.1.0/drivers/adc/: adc.c adc.h
    ../../../PDL/2.1.0/drivers/bt/: bt.c bt.h
    ../../../PDL/2.1.0/drivers/can/: can.c can.h can_pre.c can_pre.h canfd.c canfd.h
    ../../../PDL/2.1.0/drivers/clk/: clk.c clk.h
    ../../../PDL/2.1.0/drivers/cr/: cr.c cr.h
    ../../../PDL/2.1.0/drivers/dma/: dma.c dma.h
    ../../../PDL/2.1.0/drivers/gpio/: fgpio.h gpio.h
    ../../../PDL/2.1.0/drivers/mfs/: mfs.c mfs.h
    ../../../PDL/2.1.0/drivers/mft/: mft_adcmp.c mft_adcmp.h mft_frt.c mft_frt.h mft_icu.c mft_icu.h mft_ocu.c mft_ocu.h mft_wfg.c mft_wfg.h
    ../../../PDL/2.1.0/drivers/: base_types.h description.h interrupts_fm0p.h interrupts_fm0p_type_1-a.c interrupts_fm0p_type_1-b.c interrupts_fm0p_type_2-a.c interrupts_fm0p_type_2-b.c interrupts_fm0p_type_3.c interrupts_fm3.h interrupts_fm3_type_a.c interrupts_fm3_type_b.c interrupts_fm3_type_c.c interrupts_fm4.h interrupts_fm4_type_a.c interrupts_fm4_type_b.c interrupts_fm4_type_c.c pdl.c pdl.h pdl_header.h
    ../../../PDL/2.1.0/drivers/exint/: exint.c exint.h
  group include
    ./include/: pdl_user.h
  group utilities
    ../../../PDL/2.1.0/utilities/printf_scanf/: uart_io.c uart_io.h
  group cppp_board
    ./lib/cppp_board/: cppp_adc.c cppp_adc.h cppp_gfx.c cppp_gfx.h cppp_init.c cppp_init.h cppp_lcd.c cppp_lcd.h cppp_lcd_driver.c cppp_lcd_driver.h cppp_lcd_registers.h cppp_pins.h glcdfont.h joystick.c joystick.h
  group framebuffer
    ./lib/framebuffer/: framebuffer.c framebuffer.h
  group netpong
    ./lib/netpong/: NetPong.c NetPong.h NetPong_Types.h
  group phy_ir
    ./lib/phy_ir/: phy_ir.c phy_ir.h
  group sched
    ./lib/sched/: sched.c sched.h
    ./lib/sched/strdup/: strdup.c strdup.h
    ./lib/sched/timermath/: timermath.h
target S6E2CCA_Release (6090000::V6.9::.\ARMCLANG)
  device: S6E2CCAJ0A Cypress
  pack: Keil.FM4_DFP.1.5.1
  cpu: as above
  output: netpong_s6e2ccxj +hex
  c flags: Optim=7 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\common;.\common;.\include;.\lib;..\..\..\PDL\2.1.0\devices\fm4\s6e2ccxj\common;..\..\..\PDL\2.1.0\drivers;..\..\..\PDL\2.1.0\utilities;..\..\..\PDL\2.1.0\cmsis\include
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x406000 size 0xa000
  memory RVCT9: RAM 0x1ffd0000 size 0x30000
  memory RVCT10: RAM 0x20038000 size 0x10000
  scatter file: .\linker\s6e2cca_rom.sct
target S6E2CC9_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: IRAM1(0x1FFE0000,0x20000) IRAM2(0x20038000,0x10000) IROM(0x0,0x180000) IROM2(0x406000,0xA000) CPUTYPE"(Cortex-M4") FPU2 CLOCK(-1) ELITTLE
  output: s6e2ccxj_template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x1ffe0000 size 0x10000
  memory RVCT5: ROM 0x406000 size 0xa000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20038000 size 0x10000
  scatter file: .\linker\s6e2cc9_ram.sct
target S6E2CC9_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: as above
  output: s6e2ccxj_template +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x0 size 0x180000
  memory RVCT5: ROM 0x406000 size 0xa000
  memory RVCT9: RAM 0x1ffe0000 size 0x20000
  memory RVCT10: RAM 0x20038000 size 0x10000
  scatter file: .\linker\s6e2cc9_rom.sct
target S6E2CC8_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: IRAM1(0x1FFF0000,0x10000) IRAM2(0x20038000,0x10000) IROM(0x0,0x100000) IROM2(0x406000,0xA000) CPUTYPE"(Cortex-M4") FPU2 CLOCK(-1) ELITTLE
  output: s6e2ccxj_template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x1fff0000 size 0x8000
  memory RVCT5: ROM 0x406000 size 0xa000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20038000 size 0x10000
  scatter file: .\linker\s6e2cc8_ram.sct
target S6E2CC8_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: as above
  output: s6e2ccxj_template +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x406000 size 0xa000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20038000 size 0x10000
  scatter file: .\linker\s6e2cc8_rom.sct
